# Keil uVision project Attitude.uvprojx, settings and files
target Attitude (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HardWareDriver\HMC5883L;..\USER;..\IIC;..\HardWareDriver\AT45DB;..\HardWareDriver\IMU;..\HardWareDriver\Math;..\HardWareDriver\MPU6050;..\HardWareDriver\Service;..\HardWareDriver\UART1;..\HardWareDriver\USART_DMA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../README/: README.txt
  group HARD_DRIVE
    ../HardWareDriver/HMC5883L/: HMC5883L.c
    ../HardWareDriver/IMU/: IMU.c
    ../HardWareDriver/Math/: Fmath.c
    ../HardWareDriver/MPU6050/: MPU6050.c
    ../HardWareDriver/Service/: IOI2C.c report.c
